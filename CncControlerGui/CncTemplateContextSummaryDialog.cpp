#include "GlobalFunctions.h"
#include "MainFrame.h"
#include "CncConfig.h"
#include "CncTemplateContextSummaryPanel.h"
#include "CncTemplateContextSummaryDialog.h"

///////////////////////////////////////////////////////////////////
CncTemplateContextSummaryDialog::CncTemplateContextSummaryDialog(wxWindow* parent)
: CncTemplateContextSummaryDialogBase	(parent)
///////////////////////////////////////////////////////////////////
{
	swapControl();
	
	if ( parent )
	{
		wxSize size(parent->GetClientSize());
		size.Scale(0.8, 0.8);
		SetClientSize(size);
		
		CentreOnParent();
	}
}
///////////////////////////////////////////////////////////////////
CncTemplateContextSummaryDialog::~CncTemplateContextSummaryDialog() {
///////////////////////////////////////////////////////////////////
}
///////////////////////////////////////////////////////////////////
void CncTemplateContextSummaryDialog::swapControl() {
///////////////////////////////////////////////////////////////////
	if ( THE_APP )
		GblFunc::swapControls(THE_APP->getTemplateContextSummary(), m_templateContextPlaceholder);
}
///////////////////////////////////////////////////////////////////
void CncTemplateContextSummaryDialog::update() {
///////////////////////////////////////////////////////////////////
	if ( THE_APP )
		THE_APP->getTemplateContextSummary()->update();
}
///////////////////////////////////////////////////////////////////
void CncTemplateContextSummaryDialog::onCloseFromButton(wxCommandEvent& event) {
///////////////////////////////////////////////////////////////////
	swapControl();
	EndModal(wxID_OK);
}
///////////////////////////////////////////////////////////////////
void CncTemplateContextSummaryDialog::onCloseWindow(wxCloseEvent& event) {
///////////////////////////////////////////////////////////////////
	swapControl();
	EndModal(wxID_OK);
}
